# Keil uVision project mPlayer.uvproj, settings and files
target mPlayer (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: mplayer +hex
  AfterMake: fromelf --bin --output .\rvmdk\sd_card.bin .\rvmdk\sd_card.axf
  c flags: Optim=3 oTime=1 wLevel=2
  c define: rvmdk PART_LM3S6965
  c include: ..\Source\main;..\Source\buttons;..\Source\peripheral;..\Source\mp3_driver;..\Source\http_streaming;..\Source\ebook_lyrics;..\Source\graphic;..\Source\file_system;..\Source;..\Library;..\Library\third_party\lwip-1.4.1\apps;..\Library\third_party\lwip-1.4.1\ports\stellaris\include;..\Library\third_party\lwip-1.4.1\src\include;..\Library\third_party\lwip-1.4.1\src\include\ipv4;..\Library\third_party;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: sd_card.sct
  link misc: --entry Reset_Handler
  group Libraries
    ../Library/utils/: ustdlib.c
    ../Library/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ../: Read_Me_First.txt
  group Mp3
    ../Source/mp3_driver/: mp3driver.c
  group Streaming
    ../Source/http_streaming/: radio.c httpclient.c
    ../Library/utils/: lwiplib.c
  group Ebook
    ../Source/ebook_lyrics/: ebook.c
  group Peripheral
    ../Source/peripheral/: peripheral.c
  group Buttons
    ../Source/buttons/: buttons.c
  group Sdcard
    ../Library/third_party/fatfs/: mmc-ek-lm3s6965.c ff.c
    ../Source/file_system/: FileSystem.c
  group Graphic
    ../Source/graphic/: Windows.c images.c graphics.c
    ../Library/drivers/: rit128x96x4.c
  group Debug
    ../Library/utils/: uartstdio.c
  group IO
    ../Library/driverlib/: gpio.c
  group Main
    ../Source/main/: mPlayer.c Global.h startup_rvmdk.S
